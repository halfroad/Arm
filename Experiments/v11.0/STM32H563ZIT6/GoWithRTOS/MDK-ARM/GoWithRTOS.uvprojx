# Keil uVision project GoWithRTOS.uvprojx, settings and files
target STM32H563ZIT6 (6220000::V6.22::ARMCLANG)
  device: STM32H563ZITx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00050000) IRAM2(0x20050000,0x00050000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: GoWithRTOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: USE_HAL_DRIVER,STM32H563xx,USE_FULL_ASSERT
  c include: ..\Sources\Applications\Core;..\Sources\Applications\User;..\Sources\Applications\User\Configurations\Include;..\Sources\Drivers\BSP;..\Sources\Drivers\CMSIS\Include;..\Sources\Drivers\CMSIS\Device\ST\STM32H5xx\Include;..\Sources\Drivers\STM32H5xx_HAL_Driver\Inc;..\Sources\Drivers\STM32H5xx_HAL_Driver\Inc\Legacy;..\Sources\Middlewares\Third_Party\FreeRTOS\Source\include;..\Sources\Middlewares\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM33_NTZ\non_secure
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x20050000 size 0x50000
  group Applications/Core/Entry
    ../Sources/Applications/Core/Entry/Sources/: main.c
  group Applications/Core/Initializers
    ../Sources/Applications/Core/Initializers/Sources/: SystemInitializer.c
  group Applications/Core/Interrutps
    ../Sources/Applications/Core/Interrutps/Source/: stm32h5xx_it.c
  group Applications/Core/Miscellaneous
    ../Sources/Applications/Core/Miscellaneous/Source/: dcache.c icache.c memorymap.c stm32h5xx_hal_msp.c stm32h5xx_hal_timebase_tim.c
  group Applications/Core/Startup
    ../Sources/Applications/Core/Startup/: startup_stm32h563xx.s
  group Applications/User/Peripherals/Displays/DSS1306
    ../Sources/Applications/User/Peripherals/Displays/DSS1306/Source/: OLED.c
  group Applications/User/RTOS/Tasks
    ../Sources/Applications/User/RTOS/Tasks/Sources/: FlashLedTasks.c
  group Applications/User/RTOS/Wrappers
    ../Sources/Applications/User/RTOS/Wrappers/Sources/: TasksScheduler.c Wrappers.c
  group Drivers/BSP/Communications/InterIntegratedCircuits
    ../Sources/Drivers/BSP/Communications/InterIntegratedCircuits/Source/: InterIntegratedCircuits.c
  group Drivers/BSP/Communications/SerialCommunications
    ../Sources/Drivers/BSP/Communications/SerialCommunications/Source/: SerialCommunications.c
  group Drivers/BSP/Peripherals/GPIOs
    ../Sources/Drivers/BSP/Peripherals/GPIOs/Source/: GPIO.c
  group Drivers/BSP/Peripherals/Timers
    ../Sources/Drivers/BSP/Peripherals/Timers/Source/: Delay.c
  group Drivers/CMSIS/Device/ST/STM32H5xx
    ../Sources/Drivers/CMSIS/Device/ST/STM32H5xx/Source/: system_stm32h5xx.c
  group Drivers/STM32H5xx_HAL_Driver
    ../Sources/Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_dcache.c stm32h5xx_hal_gpio.c stm32h5xx_hal_icache.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_pwr.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c
  group Middlewares/Third_Party/FreeRTOS
    ../Sources/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM33_NTZ/non_secure
    ../Sources/Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM33_NTZ/non_secure/: port.c portasm.c
  group Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang
    ../Sources/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
software components: Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0
