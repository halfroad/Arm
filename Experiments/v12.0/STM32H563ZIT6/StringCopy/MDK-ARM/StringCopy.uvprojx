# Keil uVision project StringCopy.uvprojx, settings and files
target STM32H563ZIT6 (6220000::V6.22::ARMCLANG)
  device: STM32H563ZITx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00050000) IRAM2(0x20050000,0x00050000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: StringCopy +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=6 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x20050000 size 0x50000
  group Applications/Core/Startup
    ../Sources/Applications/Core/Startup/: startup_stm32h563xx.s
  group Applications/Entry
    ../Sources/Applications/Entry/Source/: main.c
  group Applications/User/Utilities
    ../Sources/Applications/User/Utilities/: Utilities.S
