# Keil uVision project BreakDeadTimeComplementaryOutputs.uvprojx, settings and files
target STM32G474VET6 (6190000::V6.19::ARMCLANG)
  device: STM32G474VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: BreakDeadTimeComplementaryOutputs +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32G474xx
  c include: ..\Application\User\Core\Inc;..\Application\User\Peripherals\Inc;..\Drivers\CMSIS\Core\Include;..\Drivers\CMSIS\Device\ST\STM32G4xx\Include;..\Drivers\STM32G4xx_HAL_Driver\Inc;..\Drivers\STM32G4xx_HAL_Driver\Inc\Legacy
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/User/Core
    ../Application/User/Core/Src/: gpio.c main.c stm32g4xx_hal_msp.c stm32g4xx_it.c
  group Application/User/Peripherals
    ../Application/User/Peripherals/Src/: BreakDeadTimeComplementaryOutputs.c
  group Drivers/CMSIS/Device/ST/STM32G4xx/Source/Templates
    ../Drivers/CMSIS/Device/ST/STM32G4xx/Source/Templates/: system_stm32g4xx.c
  group Drivers/CMSIS/Device/ST/STM32G4xx/Source/Templates/arm
    ../Drivers/CMSIS/Device/ST/STM32G4xx/Source/Templates/arm/: startup_stm32g474xx.s
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_cortex.c
