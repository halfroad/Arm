# Keil uVision project I2CAT24Cxx.uvprojx, settings and files
target STM32H755ZIT6U_CM4 (6210000::V6.21::ARMCLANG)
  device: STM32H755ZITx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x10040000,0x00008000) IRAM2(0x10000000,0x00030000) IROM(0x08100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: I2CAT24Cxx_CM4 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: STM32H755xx,CORE_CM4,USE_HSE
  c include: ..\Sources\Application\Core\Initializers\CM7\Include;..\Sources\Application\Core\Interrupts\CM7\Include;..\Sources\Application\User\Peripherals\CM7;..\Sources\Drivers\CMSIS\Include;..\Sources\Drivers\CMSIS\Device\ST\STM32H7xx\Include
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  scatter file: .\Scatters\CM4\stm32h755xx_flash_CM4.sct
  group Application/Core/Entry/CM4
    ../Sources/Application/Core/Entry/CM4/Source/: main.c
  group Application/Core/Entry/CM7
    ../Sources/Application/Core/Entry/CM7/Source/: main.c
  group Application/Core/Initializers/CM7
    ../Sources/Application/Core/Initializers/CM7/Source/: SystemInitializer.c
  group Application/Core/Interrupts/CM7
    ../Sources/Application/Core/Interrupts/CM7/Source/: SystemInterrutps.c
  group Application/User/Peripherals/CM7
    ../Sources/Application/User/Peripherals/CM7/Source/: AT24Cxx.c Delay.c InterIntegratedCircuit.c OLED.c
  group Drivers/BSP/LEDs/CM7
    ../Sources/Drivers/BSP/LEDs/CM7/Source/: GPIO.c LED.c
  group Startup/Core/Boots/CM4
    ../Sources/Startup/Core/Boots/CM4/: startup_stm32h755xx_CM4.s
  group Startup/Core/Boots/CM7
    ../Sources/Startup/Core/Boots/CM7/: startup_stm32h755xx_CM7.s
  group Startup/Core/Boots/Shared
    ../Sources/Startup/Core/Boots/Shared/: system_stm32h7xx_dualcore_boot_cm4_cm7.c
target STM32H755ZIT6U_CM7 (6210000::V6.21::ARMCLANG)
  device: STM32H755ZITx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: I2CAT24Cxx_CM7 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: STM32H755xx,CORE_CM7,USE_HSE
  c include: ..\Sources\Application\Core\Initializers\CM7\Include;..\Sources\Application\Core\Interrupts\CM7\Include;..\Sources\Application\User\Peripherals\CM7\Include;..\Sources\Drivers\BSP\LEDs\CM7\Include;..\Sources\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\Sources\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\Scatters\CM7\stm32h755xx_flash_CM7.sct
