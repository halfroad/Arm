# Keil uVision project RegisterBlinkingLED.uvprojx, settings and files
target STM32h563ZITx (6240000::V6.24::ARMCLANG)
  device: STM32H563ZITx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00050000) IRAM2(0x20050000,0x00050000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: RegisterBlinkingLED +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32H563xxx,USE_HAL_DRIVER
  c include: ..\CMSIS\Device\ST\STM32H5xx\Include;..\CMSIS\Include;..\STM32H5xx_HAL_Driver\Inc;..\STM32H5xx_HAL_Driver\Inc\Legacy;..\Users
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x20050000 size 0x50000
  group CMSIS/Device/ST/STM32H5xx/Source/Templates
    ../CMSIS/Device/ST/STM32H5xx/Source/Templates/: system_stm32h5xx.c
  group CMSIS/Device/ST/STM32H5xx/Source/Templates/arm
    ../CMSIS/Device/ST/STM32H5xx/Source/Templates/arm/: startup_stm32h563xx.s
  group STM32H5xx_HAL_Driver/Src
    ../STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c
  group Users/Applications
    ../Users/Applications/Source/: main.c SystemConfigurations.c
