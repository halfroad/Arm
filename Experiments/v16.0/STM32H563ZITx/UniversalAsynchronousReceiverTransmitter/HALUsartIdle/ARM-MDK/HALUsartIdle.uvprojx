# Keil uVision project HALUsartIdle.uvprojx, settings and files
target STM32H563ZITx (6240000::V6.24::ARMCLANG)
  device: STM32H563ZITx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00050000) IRAM2(0x20050000,0x00050000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: HALUsartIdle +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32563xx,USE_HAL_DRIVER
  c include: ..\Drivers\;..\Drivers\CMSIS\Core\Include;..\Drivers\CMSIS\Device\ST\STM32H5xx\Include;..\Drivers\CMSIS\Include;..\Drivers\STM32H5xx_HAL_Driver\Inc\Legacy;..\Drivers\STM32H5xx_HAL_Driver\Inc;..\Core
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x20050000 size 0x50000
  group Core/Applications
    ../Core/Applications/Sources/: main.c
  group Core/Systems/Initializers
    ../Core/Systems/Initializers/Sources/: SystemInitializers.c
  group Core/Systems/Miscellaneous
    ../Core/Systems/Miscellaneous/Sources/: stm32h5xx_hal_msp.c stm32h5xx_it.c
  group Drivers/BSP
    ../Drivers/BSP/Sources/: LED.c USART.c
  group Drivers/CMSIS/Device/ST/STM32H5xx/Source/Templates/arm
    ../Drivers/CMSIS/Device/ST/STM32H5xx/Source/Templates/arm/: startup_stm32h563xx.s
  group Drivers/CMSIS/Device/ST/STM32H5xx/Source/Templates
    ../Drivers/CMSIS/Device/ST/STM32H5xx/Source/Templates/: system_stm32h5xx.c
  group Drivers/STM32H5xx_HAL_Driver
    ../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c
