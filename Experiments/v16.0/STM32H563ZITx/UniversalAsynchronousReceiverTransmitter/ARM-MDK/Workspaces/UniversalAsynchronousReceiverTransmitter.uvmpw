<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <WorkspaceName>UniversalAsynchronousReceiverTransmitter</WorkspaceName>

  <project>
    <PathAndName>..\..\HALUniversalAsynchronousReceiverTransmitter\ARM-MDK\HALUniversalAsynchronousReceiverTransmitter.uvprojx</PathAndName>
    <NodeIsExpanded>1</NodeIsExpanded>
  </project>

  <project>
    <PathAndName>..\..\RegisterUniversalAsynchronousReceiverTransmitter\ARM-MDK\RegisterUniversalAsynchronousReceiverTransmitter.uvprojx</PathAndName>
    <NodeIsExpanded>1</NodeIsExpanded>
  </project>

  <project>
    <PathAndName>..\..\HALUniversalAsynchronousReceiverTransmitterIdle\ARM-MDK\HALUniversalAsynchronousReceiverTransmitterIdle.uvprojx</PathAndName>
    <NodeIsActive>1</NodeIsActive>
    <NodeIsExpanded>1</NodeIsExpanded>
  </project>

</ProjectWorkspace>
