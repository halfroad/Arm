# Keil uVision project LineInterpolation.uvprojx, settings and files
target STM32G474VETx (6210000::V6.21::ARMCLANG)
  device: STM32G474VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LineInterpolation +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32G474xx,USE_HAL_DRIVER
  c include: ..\Sources\Application\Core;..\Sources\Application\User\Peripherals;..\Sources\Application\User\RTOS;..\Sources\Drivers\BSP\Peripherals;..\Sources\Drivers\CMSIS\Device\ST\STM32G4xx\Include;..\Sources\Drivers\CMSIS\Include;..\Sources\Drivers\STM32G4xx_HAL_Driver\Inc;..\Sources\Drivers\STM32G4xx_HAL_Driver\Inc\Legacy;..\Sources\Middlewares\Third_Party\FreeRTOS\Source\include;..\Sources\Middlewares\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/Core/Boots/Startup
    ../Sources/Application/Core/Boots/Startup/: startup_stm32g474xx.s
  group Application/Core/Configurations
    ../Sources/Application/Core/Configurations/Source/: stm32g4xx_hal_msp.c stm32g4xx_hal_timebase_tim.c system_stm32g4xx.c
  group Application/Core/Entry
    ../Sources/Application/Core/Entry/Source/: main.c
  group Application/Core/Initializers
    ../Sources/Application/Core/Initializers/Source/: SystemInitializer.c
  group Application/Core/Interrutps
    ../Sources/Application/Core/Interrutps/Source/: stm32g4xx_it.c
  group Application/User/Peripherals/Displays/OLEDs
    ../Sources/Application/User/Peripherals/Displays/OLEDs/Source/: OLED.c
  group Application/User/Peripherals/Motors/StepperMotors
    ../Sources/Application/User/Peripherals/Motors/StepperMotors/Source/: StepperMotor.c StepperMotorController.c
  group Application/User/RTOS/Tasks
    ../Sources/Application/User/RTOS/Tasks/Source/: TasksScheduler.c TasksWrapper.c
  group Drivers/BSP/Peripherals/Buttons
    ../Sources/Drivers/BSP/Peripherals/Buttons/Source/: PushButton.c
  group Drivers/BSP/Peripherals/LEDs
    ../Sources/Drivers/BSP/Peripherals/LEDs/Source/: LED.c
  group Drivers/BSP/Peripherals/Timers
    ../Sources/Drivers/BSP/Peripherals/Timers/Source/: AdvancedTimer.c Delay.c
  group Drivers/BSP/Peripherals/Communications/InterIntegratedCircuits
    ../Sources/Drivers/BSP/Peripherals/Communications/InterIntegratedCircuits/Source/: InterIntegratedCircuits.c
  group Drivers/BSP/Peripherals/Communications/SerialCommunications
    ../Sources/Drivers/BSP/Peripherals/Communications/SerialCommunications/Source/: SerialCommunications.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Sources/Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_exti.c stm32g4xx_hal_gpio.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Middlewares/Third_Party/FreeRTOS
    ../Sources/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F
    ../Sources/Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang
    ../Sources/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
software components: Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0
