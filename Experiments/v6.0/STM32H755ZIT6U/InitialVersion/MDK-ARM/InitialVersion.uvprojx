# Keil uVision project InitialVersion.uvprojx, settings and files
target STM32H755ZIT6_CM4 (6190000::V6.19::ARMCLANG)
  device: STM32H755ZITx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x10040000,0x00008000) IRAM2(0x10000000,0x00030000) IROM(0x08100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: InitialVersion_CM4 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32H755xx,CORE_CM4,USE_FULL_ASSERT
  c include: ..\Sources\Applications\CM4\Configurations\Inc;..\Sources\Applications\CM4\Entry\Inc;..\Sources\Applications\CM4\Interrupts\Inc;..\Sources\Drivers\STM32H7xx_HAL_Driver\Inc;..\Sources\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy;..\Sources\Applications\Shared\Configurations\Inc;..\Sources\Applications\Shared\Peripherals\Inc;..\Sources\Applications\Shared\Tasks\Inc;..\Sources\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\Sources\Drivers\CMSIS\Include;..\Sources\Middlewares\Third_Party\FreeRTOS\Source\include;..\Sources\Middlewares\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM4F\Inc
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10040000 size 0x8000
  memory RVCT10: RAM 0x10000000 size 0x30000
  scatter file: ..\Sources\Drivers\CMSIS\Device\ST\STM32H7xx\Source\Templates\arm\linker\CM4\stm32h755xx_flash_CM4.sct
  group Applications/CM4/Entry
    ../Sources/Applications/CM4/Entry/Src/: main.c
  group Applications/CM4/Interrupts
    ../Sources/Applications/CM4/Interrupts/Src/: stm32h7xx_it.c
  group Applications/CM7/Entry
    ../Sources/Applications/CM7/Entry/Src/: main.c
  group Applications/CM7/Interrupts
    ../Sources/Applications/CM7/Interrupts/Src/: stm32h7xx_it.c
  group Applications/Shared/Peripherals
    ../Sources/Applications/Shared/Peripherals/Src/: GPIO.c
  group Applications/Shared/Tasks
    ../Sources/Applications/Shared/Tasks/Src/: TasksWrapper.c TasksOperator.c
  group Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates
    ../Sources/Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm
    ../Sources/Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h755xx.s
  group Drivers/STM32H7xx_HAL_Driver/Src
    ../Sources/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c
  group Middlewares/Third_Party/FreeRTOS/Source
    ../Sources/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/Src
    ../Sources/Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/Src/: port.c
  group Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM7/r0p1/Src
    ../Sources/Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM7/r0p1/Src/: port.c
  group Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang
    ../Sources/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
target STM32H755ZIT6_CM7 (6190000::V6.19::ARMCLANG)
  device: STM32H755ZITx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: InitialVersion_CM7 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: CORE_CM7,USE_HAL_DRIVER,STM32H755xx,USE_FULL_ASSERT
  c include: ..\Sources\Applications\CM7\Configurations\Inc;..\Sources\Applications\CM7\Entry\Inc;..\Sources\Applications\CM7\Interrupts\Inc;..\Sources\Applications\Shared\Configurations\Inc;..\Sources\Applications\Shared\Peripherals\Inc;..\Sources\Applications\Shared\Tasks\Inc;..\Sources\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\Sources\Drivers\CMSIS\Include;..\Sources\Drivers\STM32H7xx_HAL_Driver\Inc;..\Sources\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy;..\Sources\Middlewares\Third_Party\FreeRTOS\Source\include;..\Sources\Middlewares\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM7\r0p1\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\Sources\Drivers\CMSIS\Device\ST\STM32H7xx\Source\Templates\arm\linker\CM7\stm32h755xx_flash_CM7.sct
