# Keil uVision project InitialRtosVersion.uvprojx, settings and files
target STM32H755ZIT6_CM4 (6190000::V6.19::ARMCLANG)
  device: STM32H755ZITx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x10040000,0x00008000) IRAM2(0x10000000,0x00030000) IROM(0x08100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: InitialRtosVersion_CM4 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: STM32H755xx,CORE_CM4,USE_HAL_DRIVER
  c include: ..\Sources\Applications\CM4\Core\Include;..\Sources\Applications\CM4\Core\Configurations\Include;..\Sources\Applications\CM4\Core\Interrupts\Include;..\Sources\Applications\CM4\User\Initializers\Include;..\Sources\Applications\CM4\User\Peripherals\Include;..\Sources\Applications\CM4\User\RTOS\Include;..\Sources\Applications\CM4\User\RTOST\Tasks\Include;..\Sources\Applications\Shared\User\Initializers\Include;..\Sources\Applications\Shared\User\RTOS\Include;..\Sources\Drivers\CMSIS\Include;..\Sources\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\Sources\Drivers\STM32H7xx_HAL_Driver\Inc;..\Sources\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy;..\Sources\Middlewares\Third_Party\FreeRTOS\Source\include;..\Sources\Middlewares\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM4F;..\Sources\Middlewares\Third_Party\FreeRTOS\Source\portable\MemMang
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10040000 size 0x8000
  memory RVCT10: RAM 0x10000000 size 0x30000
  scatter file: .\Scatters\CM4\stm32h755xx_flash_CM4.sct
  group Applications/CM4/Core
    ../Sources/Applications/CM4/Core/Source/: main.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Applications/CM4/Core/Interrupts
    ../Sources/Applications/CM4/Core/Interrupts/Source/: stm32h7xx_it.c
  group Applications/CM4/Core/Startup
    ../Sources/Applications/CM4/Core/Startup/: startup_stm32h755xx.s system_stm32h7xx_dualcore_boot_cm4_cm7.c
  group Applications/CM4/User/Peripherals
    ../Sources/Applications/CM4/User/Peripherals/Source/: gpio.c
  group Applications/CM4/User/RTOS/Tasks
    ../Sources/Applications/CM4/User/RTOS/Source/: FlashLEDTasks.c
  group Applications/CM7/Core
    ../Sources/Applications/CM7/Core/Source/: main.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Applications/CM7/Core/Interrupts
    ../Sources/Applications/CM7/Core/Interrupts/Source/: stm32h7xx_it.c
  group Applications/CM7/Core/Startup
    ../Sources/Applications/CM7/Core/Startup/: startup_stm32h755xx.s system_stm32h7xx_dualcore_boot_cm4_cm7.c
  group Applications/CM7/User/Peripherals
    ../Sources/Applications/CM7/User/Peripherals/Source/: gpio.c
  group Applications/CM7/User/RTOS/Tasks
    ../Sources/Applications/CM7/User/RTOS/Source/: FlashLEDTasks.c
  group Applications/Shared/User/Initializers
    ../Sources/Applications/Shared/User/Initializers/Source/: SystemInitializer.c
  group Applications/Shared/User/RTOS
    ../Sources/Applications/Shared/User/RTOS/Source/: TasksWrapper.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Sources/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_gpio.c stm32h7xx_hal_rcc.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c
  group Middlewares/Third_Party/FreeRTOS
    ../Sources/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F
    ../Sources/Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang
    ../Sources/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
target STM32H755ZIT6_CM7 (6190000::V6.19::ARMCLANG)
  device: STM32H755ZITx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: InitialRtosVersion_CM7 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: STM32H755xx,CORE_CM7,USE_HAL_DRIVER
  c include: ..\Sources\Applications\CM7\Core\Include;..\Sources\Applications\CM7\Core\Configurations\Include;..\Sources\Applications\CM7\Core\Interrupts\Include;..\Sources\Applications\CM7\User\Initializers\Include;..\Sources\Applications\CM7\User\Peripherals\Include;..\Sources\Applications\CM7\User\RTOS\Include;..\Sources\Applications\CM7\User\RTOST\Tasks\Include;..\Sources\Applications\Shared\User\Initializers\Include;..\Sources\Applications\Shared\User\RTOS\Include;..\Sources\Drivers\CMSIS\Include;..\Sources\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\Sources\Drivers\STM32H7xx_HAL_Driver\Inc;..\Sources\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy;..\Sources\Middlewares\Third_Party\FreeRTOS\Source\include;..\Sources\Middlewares\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM4F;..\Sources\Middlewares\Third_Party\FreeRTOS\Source\portable\MemMang
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\Scatters\CM7\stm32h755xx_flash_CM7.sct
software components: Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0
