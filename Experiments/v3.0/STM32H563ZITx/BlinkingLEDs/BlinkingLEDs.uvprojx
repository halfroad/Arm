# Keil uVision project BlinkingLEDs.uvprojx, settings and files
target BlinkingLEDs (6190000::V6.19::ARMCLANG)
  device: STM32H563ZITx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x2009FFFF) IROM(0x08000000-0x81FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: BlinkingLEDs +hex
  c flags: OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER
  c include: .\Application\Core\Entry\Inc;.\Application\Core\Initializers\Inc;.\Application\Core\Interrupts\Inc;.\Application\Core\Periphes\Inc;.\Drivers\CMSIS\Core\Include;.\Drivers\CMSIS\Device\ST\STM32H5xx\Include;.\Drivers\CMSIS\Include;.\Drivers\STM32H5xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group Application/Entry
    ./Application/Core/Entry/Src/: main.c
  group Application/Initializers
    ./Application/Core/Initializers/Src/: icache.c stm32h5xx_hal_msp.c
  group Application/Interrupts
    ./Application/Core/Interrupts/Src/: stm32h5xx_it.c
  group Application/Periphes
    ./Application/Core/Periphes/Src/: gpio.c usart.c
  group Application/Startup
    ./Application/Startups/: startup_stm32h563xx.s
  group Drivers/CMSIS
    ./Drivers/CMSIS/Device/ST/STM32H5xx/Source/: system_stm32h5xx.c
  group Drivers/STM32H5xx_HAL_Driver
    ./Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_ll_utils.c stm32h5xx_hal_cortex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_gpio.c
