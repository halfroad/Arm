# Keil uVision project SystemTicks.uvprojx, settings and files
target STM32H563ZITx (6190000::V6.19::ARMCLANG)
  device: STM32H563ZITx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00050000) IRAM2(0x20050000,0x00050000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: SystemTicks +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c include: .\Sources\Application\Core\Entry\Inc;.\Sources\Application\Core\Initializers\Inc;.\Sources\Application\Core\Interrupts\Inc;.\Sources\Application\Core\Periphes\Inc;.\Sources\Drivers\CMSIS\Core\Include;.\Sources\Drivers\CMSIS\Device\ST\STM32H5xx\Include;.\Sources\Drivers\CMSIS\Include;.\Sources\Drivers\STM32H5xx_HAL_Driver\Inc;.\Sources\Drivers\STM32H5xx_HAL_Driver\Inc\Legacy
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x20050000 size 0x50000
  group Application/Core/Entry
    ./Sources/Application/Core/Entry/Src/: main.c
  group Application/Core/Initializers
    ./Sources/Application/Core/Initializers/Src/: stm32h5xx_hal_msp.c cache.c
  group Application/Core/Interrupts
    ./Sources/Application/Core/Interrupts/Src/: stm32h5xx_it.c
  group Application/Core/Periphes
    ./Sources/Application/Core/Periphes/Src/: gpio.c usart.c delay.c
  group Application/Startups
    ./Sources/Application/Startups/: startup_stm32h563xx.s
  group Drivers/CMSIS/Device/ST/STM32H5xx
    ./Sources/Drivers/CMSIS/Device/ST/STM32H5xx/Source/: system_stm32h5xx.c
  group Drivers/STM32H5xx_HAL_Driver
    ./Sources/Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_ll_utils.c stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_gpio.c
