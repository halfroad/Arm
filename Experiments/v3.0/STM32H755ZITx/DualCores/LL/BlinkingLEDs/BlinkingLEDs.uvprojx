# Keil uVision project BlinkingLEDs.uvprojx, settings and files
target STM32H755ZITx_CM4 (6190000::V6.19::ARMCLANG)
  device: STM32H755ZITx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x10040000,0x00008000) IRAM2(0x10000000,0x00030000) IROM(0x08100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BlinkingLEDs_CM4 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: CORE_CM4,USE_FULL_LL_DRIVER,STM32H755xx
  c include: .\Sources\Applications\CM4\Core\Inc;.\Sources\Drivers\CMSIS\Core\Include;.\Sources\Drivers\CMSIS\Device\ST\STM32H7xx\Include;.\Sources\Drivers\STM32H7xx_HAL_Driver\Inc;.\Sources\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy;.\Sources\Startups\Inc
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  scatter file: .\Scatters\stm32h755xx_flash_CM4.sct
  group Applications/CM4/Core
    ./Sources/Applications/CM4/Core/Src/: gpio.c main.c stm32h7xx_it.c
  group Applications/CM7/Core
    ./Sources/Applications/CM7/Core/Src/: gpio.c main.c stm32h7xx_it.c
  group Drivers/STM32H7xx_Driver
    ./Sources/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_ll_gpio.c stm32h7xx_ll_utils.c stm32h7xx_ll_rcc.c
  group Startups
    ./Sources/Startups/Src/: startup_stm32h755xx_CM4.s startup_stm32h755xx_CM7.s system_stm32h7xx_dualcore_boot_cm4_cm7.c
target STM32H755ZITx_CM7 (6190000::V6.19::ARMCLANG)
  device: STM32H755ZITx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: BlinkingLEDs_CM7 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: CORE_CM7,USE_FULL_LL_DRIVER,STM32H755xx
  c include: .\Sources\Applications\CM7\Core\Inc;.\Sources\Drivers\CMSIS\Core\Include;.\Sources\Drivers\CMSIS\Device\ST\STM32H7xx\Include;.\Sources\Drivers\STM32H7xx_HAL_Driver\Inc;.\Sources\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy;.\Sources\Startups\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\Scatters\stm32h755xx_flash_CM7.sct
