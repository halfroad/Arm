# Keil uVision project BlinkyLEDs.uvprojx, settings and files
target STM32H563ZITx (6240000::V6.24::ARMCLANG)
  device: STM32H563ZITx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00050000) IRAM2(0x20050000,0x00050000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: BlinkyLEDs +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER
  c misc: -Wno-invalid-source-encoding
  c include: ..\..\Core;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32H5xx\Include;..\..\Drivers\STM32H5xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x20050000 size 0x50000
  group Core
    ../../Core/Src/: main.c system_stm32h5xx.c stm32h5xx_it.c
  group Core/Startup
    ../../Core/Startup/: startup_stm32h563xx.s
  group Drivers/STM32H5xx_HAL_Driver
    ../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_rcc.c stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_gpio.c
