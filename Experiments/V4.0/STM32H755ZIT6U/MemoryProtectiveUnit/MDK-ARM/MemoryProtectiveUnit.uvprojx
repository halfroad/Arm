# Keil uVision project MemoryProtectiveUnit.uvprojx, settings and files
target STM32H755ZIT6U_CM4 (6190000::V6.19::ARMCLANG)
  device: STM32H755ZITx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x10040000,0x00008000) IRAM2(0x10000000,0x00030000) IROM(0x08100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MemoryProtectiveUnit_CM4 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: STM32H755xx,CORE_CM4,USE_HSE
  c include: ..\Sources\Application\CM4\Entry\Include;..\Sources\Application\CM4\Initializers\Include;..\Sources\Application\CM4\Interrupts\Include;..\Sources\Application\CM4\Peripherals\Include;..\Sources\Drivers\CMSIS\Include;..\Sources\Drivers\CMSIS\Device\ST\STM32H7xx\Include
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  scatter file: .\Scatters\CM4\stm32h755xx_flash_CM4.sct
  group Application/CM4/Entry
    ../Sources/Application/CM4/Entry/Source/: Entry.c
  group Application/CM4/Initializers
    ../Sources/Application/CM4/Initializers/Source/: SystemInitializer.c
  group Application/CM7/Entry
    ../Sources/Application/CM7/Entry/Source/: Entry.c
  group Application/CM7/Hardwares
    ../Sources/Application/CM7/Hardwares/Source/: MemoryProtectiveUnit.c
  group Application/CM7/Initializers
    ../Sources/Application/CM7/Initializers/Source/: SystemInitializer.c
  group Application/CM7/Interrupts
    ../Sources/Application/CM7/Interrupts/Source/: SystemInterrutps.c ExtendedInterrupts.c
  group Application/CM7/Peripherals
    ../Sources/Application/CM7/Peripherals/Source/: Delay.c OLED.c GPIO.c
  group Independence/Shared
    ../Sources/Common/Src/: system_stm32h7xx_dualcore_boot_cm4_cm7.c
  group Startups/CM4
    ../Sources/Startups/CM4/: startup_stm32h755xx_CM4.s
  group Startups/CM7
    ../Sources/Startups/CM7/: startup_stm32h755xx_CM7.s
target STM32H755ZIT6U_CM7 (6190000::V6.19::ARMCLANG)
  device: STM32H755ZITx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: MemoryProtectiveUnit_CM7 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: STM32H755xx,CORE_CM7,USE_HSE
  c include: ..\Sources\Application\CM7\Entry\Include;..\Sources\Application\CM7\Hardwares\Include;..\Sources\Application\CM7\Initializers\Include;..\Sources\Application\CM7\Interrupts\Include;..\Sources\Application\CM7\Peripherals\Include;..\Sources\Drivers\CMSIS\Include;..\Sources\Drivers\CMSIS\Device\ST\STM32H7xx\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\Scatters\CM7\stm32h755xx_flash_CM7.sct
