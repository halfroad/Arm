# Keil uVision project DirectMemoryAccessSerialCommunication.uvprojx, settings and files
target STM32H563ZITx (6190000::V6.19::ARMCLANG)
  device: STM32H563ZITx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00050000) IRAM2(0x20050000,0x00050000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: DirectMemoryAccessSerialCommunication +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=25000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=64000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,ART_ACCELERATOR_ENABLE=0,STM32H563xx
  c include: .\Sources\Startup\inc;.\Sources\Drivers\CMSIS\inc;.\Sources\Drivers\STM32H5xx_LL_Drivers\inc;.\Sources\Application\Entry\inc;.\Sources\Application\Initializers\inc;.\Sources\Application\Peripherals\inc;.\Sources\Application\Interrupts\inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x20050000 size 0x50000
  group Startup/STM32H5xx_Startup
    ./Sources/Startup/src/: startup_stm32h563xx.s
  group Drivers/CMSIS
    ./Sources/Drivers/CMSIS/src/: system_stm32h5xx.c
  group Drivers/STM32H5xx_LL_Drivers
    ./Sources/Drivers/STM32H5xx_LL_Drivers/src/: stm32h5xx_ll_gpio.c stm32h5xx_ll_icache.c stm32h5xx_ll_pwr.c stm32h5xx_ll_rcc.c stm32h5xx_ll_usart.c stm32h5xx_ll_utils.c stm32h5xx_ll_dac.c stm32h5xx_ll_dma.c
  group Application/Entry
    ./Sources/Application/Entry/src/: main.c
  group Application/Initializers
    ./Sources/Application/Initializers/src/: initializers.c
  group Application/Peripherals
    ./Sources/Application/Peripherals/src/: gpio.c usart_gpio.c usart.cpp dam.c
  group Application/Interrupts
    ./Sources/Application/Interrupts/src/: stm32h5xx_it.c
