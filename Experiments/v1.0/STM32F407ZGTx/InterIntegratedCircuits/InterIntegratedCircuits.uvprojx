# Keil uVision project InterIntegratedCircuits.uvprojx, settings and files
target STM32F407ZGTx (6190000::V6.19::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: InterIntegratedCircuits +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 wLevel=3
  c define: STM32F40_41xxx,STM32F40_41xxx_DEVEBOX,USE_STDPERIPH_DRIVER
  c include: .\Sources\CMSIS\Includes;.\Sources\StandardPeripheralDrivers\Includes;.\Sources\Startup\Includes;.\Sources\User\Includes
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ./Sources/CMSIS/Sources/: stm32f4xx_it.c system_stm32f4xx.c
  group StandardPeripheralDrivers
    ./Sources/StandardPeripheralDrivers/Sources/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_i2c.c stm32f4xx_tim.c misc.c stm32f4xx_usart.c
  group Startup
    ./Sources/Startup/Sources/: startup_stm32f40_41xxx.s
  group User
    ./Sources/User/Sources/: main.c InterIntegratedCircuits.c Timer.c EEPROM.c USART.c GPIO.c
software components: CMSIS:CORE 5.6.0
